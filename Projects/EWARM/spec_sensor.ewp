# IAR project spec_sensor.ewp, settings and files
configuration spec_sensor Configuration (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\Drivers\STM32F3xx_HAL_Driver\Inc; ..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\Drivers\CMSIS\Include; ..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: spec_sensor Configuration.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s
  group Application/User
    ../../Src/: freertos.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_ll_usb.c
  group Middlewares/FreeRTOS
    ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/USB_Device_Library
    ../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
